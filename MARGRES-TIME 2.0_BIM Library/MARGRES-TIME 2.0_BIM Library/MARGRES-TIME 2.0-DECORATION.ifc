Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON:107868
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T28P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T28P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T28P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON; Type Id: 108028
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM:110775
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T23P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T23P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T23P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; Type Id: 110795
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE:107233
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T25P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T25P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T25P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE; Type Id: 107257
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY:107609
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T27P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T27P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T27P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY; Type Id: 107766
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER:107493
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T26P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T26P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T26P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER; Type Id: 107519
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW:105875
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T21P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T21P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T21P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW; Type Id: 105892
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE:106210
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T22P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T22P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T22P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE; Type Id: 106236
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
