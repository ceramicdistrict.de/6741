Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW:95729
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T21P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T21P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T21P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW; Type Id: 61076
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE:95906
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T22P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T22P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T22P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-WHITE; Type Id: 61078
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE:106847
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - ANSI A137.1-Shade Variation: CCC (China Compulsory Product Certification); CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-ASR-BEIGE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T24NR; SASO Quality Mark (QM): ANSI A137.1 (Shade Variation); Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T24NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T24NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE; Type Id: 106936
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK:108096
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T29NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T29NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T29NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK; Type Id: 108195
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON:107861
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T28NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T28NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T28NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON; Type Id: 107967
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM:106523
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T23NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T23NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T23NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM; Type Id: 106603
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE:107074
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T25NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T25NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T25NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE; Type Id: 107165
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY:107602
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-ASR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T27NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T27NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T27NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY; Type Id: 107720
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER:107343
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-ASR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T26NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T26NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T26NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER; Type Id: 107432
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW:105742
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T21NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M310T21NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M310T21NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW; Type Id: 105777
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE:106400
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T22P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T22P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T22P
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE; Type Id: 106448
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE:90199
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Absorptance: 0.1; Roughness: 1
Type - Construction - Default Thickness: 10 mm; Function: Exterior
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T24ASR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T24ASR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T24ASR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Area: 1 m2; Elevation at Bottom: -10 mm; Elevation at Top: 0 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE; Type Id: 61692
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK:90257
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Exterior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T29ASR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T29ASR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T29ASR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK; Type Id: 61694
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CARBON, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CARBON:90304
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CARBON 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Exterior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CARBON; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T28ASR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T28ASR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T28ASR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CARBON; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CARBON; Type Id: 61696
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM:90336
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Exterior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T23ASR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T23ASR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T23ASR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Type Id: 61698
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER:90400
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Exterior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T26ASR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T26ASR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T26ASR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; Type Id: 61700
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW:90436
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Exterior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T21ASR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T21ASR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T21ASR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Type Id: 61702
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE:106840
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BEIGE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T24NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T24NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T24NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE; Type Id: 106872
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK:108089
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T29NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T29NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T29NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK; Type Id: 108131
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON:107854
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T28NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T28NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T28NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON; Type Id: 107896
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM:106516
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T23NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T23NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T23NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM; Type Id: 106550
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE:107067
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T25NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T25NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T25NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE; Type Id: 107101
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY:107595
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T27NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T27NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T27NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY; Type Id: 107639
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER:107336
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T26NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T26NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T26NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER; Type Id: 107368
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW:105650
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T21NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T21NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T21NR
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW; Type Id: 105670
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE:106038
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T22P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T22P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T22P
Pset_CoveringCommon - TotalThickness: 10 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -10 mm; Perimeter: 4000 mm; Thickness: 10 mm; Volume: 0.01 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE; Type Id: 106080
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE:106724
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-BLACK; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T24P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T24P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T24P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE; Type Id: 106746
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK:108103
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-ASR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T29P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Floors; Family Name: Floor
Type - Pset_CoveringCommon - Reference: M33T29P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Floors
Type - Pset_QuantityTakeOff - Reference: M33T29P
Pset_CoveringCommon - TotalThickness: 9.5 mm
Constraints - Height Offset From Level: 0 mm; Level: Level 1; Related to Mass: no; Room Bounding: yes
Dimensions - Elevation at Top: 0 mm; Area: 1 m2; Elevation at Bottom: -9.5 mm; Perimeter: 4000 mm; Thickness: 9.5 mm; Volume: 0.0095 m3
Other - Family: Floor; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK; Family and Type: Floor: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK; Type Id: 108256
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no

# IfcCovering: Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON, Floor:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON:107868
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Default Thickness: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
