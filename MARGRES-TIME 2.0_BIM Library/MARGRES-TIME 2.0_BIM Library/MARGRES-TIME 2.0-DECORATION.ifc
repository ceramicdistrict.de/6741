Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-03-31T18:22:14
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 03/2023
Text - Library Version: V03

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 03/2023
Text - Library Version: V03

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1604
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE:90986
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T24NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T24NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T24NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BEIGE; Type Id: 60996
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK:94802
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T29NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T29NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T29NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-BLACK; Type Id: 60998
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON:94964
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T28NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T28NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T28NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CARBON; Type Id: 61000
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM:95117
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T23NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T23NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T23NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-CREAM; Type Id: 61002
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE:95270
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T25NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T25NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T25NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-DOVE; Type Id: 61004
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY:95427
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T27NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T27NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T27NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-GREY; Type Id: 61006
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER:95576
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T26NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T26NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T26NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SILVER; Type Id: 61008
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW:95730
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T21NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T21NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T21NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-SNOW; Type Id: 61010
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE:95907
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M310T22NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M310T22NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M310T22NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X10-NR-WHITE; Type Id: 61012
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE:90506
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Width: 10 mm; Wrapping at Inserts: Do not wrap
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T24NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T24NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T24NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BEIGE; Type Id: 61044
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK:94800
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T29NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T29NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T29NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-BLACK; Type Id: 61046
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON:94962
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T28NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T28NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T28NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CARBON; Type Id: 61048
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM:95115
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T23NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T23NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T23NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-CREAM; Type Id: 61050
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE:95268
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T25NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T25NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T25NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-DOVE; Type Id: 61052
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY:95425
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T27NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T27NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T27NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-GREY; Type Id: 61054
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER:95574
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T26NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T26NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T26NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SILVER; Type Id: 61056
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW:95728
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T21NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T21NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T21NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-SNOW; Type Id: 61058
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE:95905
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE 10 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 10 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T22NR; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T22NR
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T22NR
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.01 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-NR-WHITE; Type Id: 61060
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE:90886
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T24P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T24P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T24P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BEIGE; Type Id: 61062
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK:94801
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T29P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T29P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T29P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-BLACK; Type Id: 61064
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON:94963
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T28P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T28P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T28P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CARBON; Type Id: 61066
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM:95116
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T23P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T23P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T23P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-CREAM; Type Id: 61068
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE:95269
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T25P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T25P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T25P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-DOVE; Type Id: 61070
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY:95426
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T27P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T27P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T27P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-GREY; Type Id: 61072
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER:95575
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
Type - Analytical Properties - Roughness: 1; Absorptance: 0.1
Type - Construction - Function: Interior; Wrapping at Inserts: Do not wrap; Width: 9.5 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Graphics - Coarse Scale Fill Color: 0
Type - Identity Data - CCC-China Compulsory Product Certification: Guaranteed; GOST-R: Guaranteed; Greenguard Gold: Guaranteed; Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER; Product Type-EN 14411: Annex G - UGL; Product Type-ISO 13006: Annex G - UGL; Reference: M33T26P; Type Name: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Other - Category: Walls; Family Name: Basic Wall
Type - Pset_CoveringCommon - Reference: M33T26P
Type - Pset_ElementShading - Roughness: 304.8 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls
Type - Pset_QuantityTakeOff - Reference: M33T26P
Constraints - Related to Mass: no; Room Bounding: yes; Base Constraint: Level 1; Base Extension Distance: 0 mm; Base is Attached: no; Base Offset: 0 mm; Location Line: Finish Face: Exterior; Top Extension Distance: 0 mm; Top is Attached: no; Top Offset: 0 mm; Unconnected Height: 1000 mm
Cross-Section Definition - Cross-Section: Vertical
Dimensions - Area: 1 m2; Length: 1000 mm; Volume: 0.0095 m3
Other - Family: Basic Wall; Family and Type: Basic Wall: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER; Type: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SILVER; Type Id: 61074
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_CoveringCommon - sets with these values: 2

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW, Basic Wall:MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW:95729
In: Level 1
Type - PredefinedType: CLADDING; Material: MARGRES-TIME 2.0-DECORATION-30X30_3,5X3,5-P-SNOW 9.5 mm
Type - Analysis Results - Area per Piece: 0.09 m2
