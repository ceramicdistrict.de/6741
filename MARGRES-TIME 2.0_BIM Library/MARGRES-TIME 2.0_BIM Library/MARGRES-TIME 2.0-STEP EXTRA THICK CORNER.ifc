Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-03-31T18:32:48
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1813
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcCovering: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:LEFT CORNER-30x120-NR-CREAM, MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:LEFT CORNER-30x120-NR-CREAM:5439
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 299.9 mm; Thickness: 10.5 mm; Width: 1203.6 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/202; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 32T23DCENR; Type Comments: Step Extra Thick Corner; Type Name: LEFT CORNER-30x120-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X120-NR-CREAM
Type - Other - Category: Generic Models; Step Corner: MARGRES-TIME2.0-SETLC; Family Name: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER
Type - Pset_CoveringCommon - Reference: 32T23DCENR; Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X120-NR-CREAM; TotalThickness: 10.5 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32T23DCENR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X120-NR-CREAM
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.448007 m2; Volume: 0.00455623 m3
Other - Family: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER; Family and Type: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER: LEFT CORNER-30x120-NR-CREAM; Type: LEFT CORNER-30x120-NR-CREAM; Type Id: 5394
Phasing - Phase Created: New Construction

# IfcCovering: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:LEFT CORNER-30x60-NR-BEIGE, MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:LEFT CORNER-30x60-NR-BEIGE:5425
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 299.9 mm; Thickness: 10 mm; Width: 601.8 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/202; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 36T24DCENR; Type Comments: Step Extra Thick Corner; Type Name: LEFT CORNER-30x60-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X60-NR-BEIGE
Type - Other - Category: Generic Models; Family Name: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER; Step Corner: MARGRES-TIME2.0-SETLC
Type - Pset_CoveringCommon - Reference: 36T24DCENR; Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X60-NR-BEIGE; TotalThickness: 10 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 36T24DCENR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X60-NR-BEIGE
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.232274 m2; Volume: 0.00226963 m3
Other - Family: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER; Family and Type: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER: LEFT CORNER-30x60-NR-BEIGE; Type: LEFT CORNER-30x60-NR-BEIGE; Type Id: 5372
Phasing - Phase Created: New Construction

# IfcCovering: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:RIGHT CORNER-30x120-NR-CREAM, MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:RIGHT CORNER-30x120-NR-CREAM:5469
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 299.9 mm; Thickness: 10.5 mm; Width: 1203.6 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/202; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 32T23DCDNR; Type Comments: Step Extra Thick Corner; Type Name: RIGHT CORNER-30x120-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X120-NR-CREAM
Type - Other - Category: Generic Models; Step Corner: MARGRES-TIME2.0-SETRC; Family Name: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER
Type - Pset_CoveringCommon - Reference: 32T23DCDNR; Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X120-NR-CREAM; TotalThickness: 10.5 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32T23DCDNR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X120-NR-CREAM
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.452338 m2; Volume: 0.00527815 m3
Other - Family: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER; Family and Type: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER: RIGHT CORNER-30x120-NR-CREAM; Type: RIGHT CORNER-30x120-NR-CREAM; Type Id: 5334
Phasing - Phase Created: New Construction

# IfcCovering: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:RIGHT CORNER-30x60-NR-BEIGE, MARGRES-TIME 2.0-STEP EXTRA THICK CORNER:RIGHT CORNER-30x60-NR-BEIGE:5453
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 299.9 mm; Thickness: 10 mm; Width: 601.8 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/202; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 36T24DCDNR; Type Comments: Step Extra Thick Corner; Type Name: RIGHT CORNER-30x60-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X60-NR-BEIGE
Type - Other - Category: Generic Models; Family Name: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER; Step Corner: MARGRES-TIME2.0-SETRC
Type - Pset_CoveringCommon - Reference: 36T24DCDNR; Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X60-NR-BEIGE; TotalThickness: 10 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 36T24DCDNR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER-30X60-NR-BEIGE
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.234835 m2; Volume: 0.00263059 m3
Other - Family: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER; Family and Type: MARGRES-TIME 2.0-STEP EXTRA THICK CORNER: RIGHT CORNER-30x60-NR-BEIGE; Type: RIGHT CORNER-30x60-NR-BEIGE; Type Id: 5312
Phasing - Phase Created: New Construction
