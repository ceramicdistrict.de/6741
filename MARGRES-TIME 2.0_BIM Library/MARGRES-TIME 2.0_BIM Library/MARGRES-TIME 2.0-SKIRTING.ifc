Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-SILVER:99906
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-NR-SILVER; Reference: 89T26NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-NR-SILVER
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T26NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 2980 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-NR-SILVER; Type: MARGRES-TIME 2.0-SKIRTING-8x90-NR-SILVER; Type Id: 97375
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-SNOW, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-SNOW:100055
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-NR-SNOW; Reference: 89T21NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-NR-SNOW
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T21NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 2980 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-NR-SNOW; Type: MARGRES-TIME 2.0-SKIRTING-8x90-NR-SNOW; Type Id: 97376
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-BEIGE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-BEIGE:99162
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-P-BEIGE; Reference: 89T24P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-P-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-P-BEIGE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T24P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 12280 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-P-BEIGE; Type: MARGRES-TIME 2.0-SKIRTING-8x90-P-BEIGE; Type Id: 97377
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-BLACK, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-BLACK:99276
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-P-BLACK; Reference: 89T29P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-P-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-P-BLACK
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T29P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 12280 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-P-BLACK; Type: MARGRES-TIME 2.0-SKIRTING-8x90-P-BLACK; Type Id: 97378
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-CARBON, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-CARBON:99384
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-P-CARBON; Reference: 89T28P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-P-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-P-CARBON
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T28P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 12280 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-P-CARBON; Type: MARGRES-TIME 2.0-SKIRTING-8x90-P-CARBON; Type Id: 97379
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-CREAM, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-CREAM:99515
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-P-CREAM; Reference: 89T23P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-P-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-P-CREAM
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T23P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 12280 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-P-CREAM; Type: MARGRES-TIME 2.0-SKIRTING-8x90-P-CREAM; Type Id: 97380
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-SILVER:99910
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-P-SILVER; Reference: 89T26P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-P-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-P-SILVER
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T26P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 2980 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-P-SILVER; Type: MARGRES-TIME 2.0-SKIRTING-8x90-P-SILVER; Type Id: 97381
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-SNOW, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-P-SNOW:100059
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-P-SNOW; Reference: 89T21P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-P-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-P-SNOW
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T21P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 2980 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-P-SNOW; Type: MARGRES-TIME 2.0-SKIRTING-8x90-P-SNOW; Type Id: 97382
Phasing - Phase Created: New Construction
