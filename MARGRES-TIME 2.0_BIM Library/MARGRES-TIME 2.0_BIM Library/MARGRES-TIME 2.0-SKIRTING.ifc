Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-03-31T18:23:44
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 03/2023
Text - Library Version: V03

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 03/2023
Text - Library Version: V03

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1604
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-BLACK, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-BLACK:99271
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 11
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-NR-BLACK; Reference: 82T29NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-NR-BLACK
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T29NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 10320 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-NR-BLACK; Type: MARGRES-TIME 2.0-SKIRTING-8x120-NR-BLACK; Type Id: 97383
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-CREAM, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-CREAM:99510
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 11
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-NR-CREAM; Reference: 82T23NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-NR-CREAM
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T23NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 10320 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-NR-CREAM; Type: MARGRES-TIME 2.0-SKIRTING-8x120-NR-CREAM; Type Id: 97384
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-GREY, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-GREY:99781
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 11
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-NR-GREY; Reference: 82T27NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-NR-GREY; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-NR-GREY
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T27NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T27NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-NR-GREY; Type: MARGRES-TIME 2.0-SKIRTING-8x120-NR-GREY; Type Id: 97385
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-SILVER:99905
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 11
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-NR-SILVER; Reference: 82T26NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-NR-SILVER
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T26NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-NR-SILVER; Type: MARGRES-TIME 2.0-SKIRTING-8x120-NR-SILVER; Type Id: 97386
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-SNOW, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-SNOW:100054
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 11
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-NR-SNOW; Reference: 82T21NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-NR-SNOW
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T21NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-NR-SNOW; Type: MARGRES-TIME 2.0-SKIRTING-8x120-NR-SNOW; Type Id: 97387
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-WHITE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-NR-WHITE:100235
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-NR-WHITE; Reference: 82T22NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-NR-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-NR-WHITE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T22NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-NR-WHITE; Type: MARGRES-TIME 2.0-SKIRTING-8x120-NR-WHITE; Type Id: 97388
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-BLACK, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-BLACK:99275
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-P-BLACK; Reference: 82T29P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-P-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-P-BLACK
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T29P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 10320 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-P-BLACK; Type: MARGRES-TIME 2.0-SKIRTING-8x120-P-BLACK; Type Id: 97389
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-CREAM, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-CREAM:99514
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-P-CREAM; Reference: 82T23P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-P-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-P-CREAM
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T23P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 10320 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-P-CREAM; Type: MARGRES-TIME 2.0-SKIRTING-8x120-P-CREAM; Type Id: 97390
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-GREY, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-GREY:99785
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-P-GREY; Reference: 82T27P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-P-GREY; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-P-GREY
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T27P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T27P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-P-GREY; Type: MARGRES-TIME 2.0-SKIRTING-8x120-P-GREY; Type Id: 97391
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-SILVER:99909
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-P-SILVER; Reference: 82T26P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-P-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-P-SILVER
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T26P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-P-SILVER; Type: MARGRES-TIME 2.0-SKIRTING-8x120-P-SILVER; Type Id: 97392
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-SNOW, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-SNOW:100058
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-P-SNOW; Reference: 82T21P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-P-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-P-SNOW
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T21P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-P-SNOW; Type: MARGRES-TIME 2.0-SKIRTING-8x120-P-SNOW; Type Id: 97393
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-WHITE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x120-P-WHITE:100239
In: Level 1
Type - Analysis Results - Length per Piece: 1202.6 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X120-P-WHITE; Reference: 82T22P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x120-P-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X120-P-WHITE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 82T22P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 82T22P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x120-P-WHITE; Type: MARGRES-TIME 2.0-SKIRTING-8x120-P-WHITE; Type Id: 97394
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-BEIGE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-BEIGE:99014
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-BEIGE; Reference: 86T24NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-BEIGE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T24NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-BEIGE; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-BEIGE; Type Id: 97353
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-BLACK, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-BLACK:99273
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-BLACK; Reference: 86T29NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-BLACK
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T29NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-BLACK; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-BLACK; Type Id: 97354
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-CARBON, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-CARBON:99381
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-CARBON; Reference: 86T28NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-CARBON
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T28NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-CARBON; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-CARBON; Type Id: 97355
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-CREAM, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-CREAM:99512
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-CREAM; Reference: 86T23NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-CREAM
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T23NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-CREAM; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-CREAM; Type Id: 97356
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-DOVE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-DOVE:99630
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-DOVE; Reference: 86T25NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-DOVE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T25NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T25NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-DOVE; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-DOVE; Type Id: 97357
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-GREY, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-GREY:99783
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-GREY; Reference: 86T27NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-GREY; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-GREY
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T27NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T27NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-GREY; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-GREY; Type Id: 97358
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-SILVER:99907
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-SILVER; Reference: 86T26NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-SILVER
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T26NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-SILVER; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-SILVER; Type Id: 97359
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-SNOW, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-SNOW:100056
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-SNOW; Reference: 86T21NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-SNOW
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T21NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-SNOW; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-SNOW; Type Id: 97360
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-WHITE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-NR-WHITE:100237
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 10
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-NR-WHITE; Reference: 86T22NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-NR-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-NR-WHITE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T22NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-NR-WHITE; Type: MARGRES-TIME 2.0-SKIRTING-8x60-NR-WHITE; Type Id: 97361
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-BEIGE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-BEIGE:99163
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-BEIGE; Reference: 86T24P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-BEIGE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T24P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-BEIGE; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-BEIGE; Type Id: 97362
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-BLACK, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-BLACK:99277
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-BLACK; Reference: 86T29P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-BLACK
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T29P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-BLACK; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-BLACK; Type Id: 97363
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-CARBON, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-CARBON:99385
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-CARBON; Reference: 86T28P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-CARBON
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T28P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-CARBON; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-CARBON; Type Id: 97364
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-CREAM, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-CREAM:99516
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-CREAM; Reference: 86T23P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-CREAM
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T23P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-CREAM; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-CREAM; Type Id: 97365
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-DOVE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-DOVE:99634
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-DOVE; Reference: 86T25P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-DOVE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T25P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T25P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 14360 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-DOVE; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-DOVE; Type Id: 97366
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-GREY, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-GREY:99787
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-GREY; Reference: 86T27P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-GREY; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-GREY
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T27P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T27P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-GREY; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-GREY; Type Id: 97367
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-SILVER:99911
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-SILVER; Reference: 86T26P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-SILVER
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T26P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-SILVER; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-SILVER; Type Id: 97368
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-SNOW, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-SNOW:100060
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-SNOW; Reference: 86T21P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-SNOW
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T21P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-SNOW; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-SNOW; Type Id: 97369
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-WHITE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x60-P-WHITE:100241
In: Level 1
Type - Analysis Results - Length per Piece: 600.8 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X60-P-WHITE; Reference: 86T22P; Type Name: MARGRES-TIME 2.0-SKIRTING-8x60-P-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X60-P-WHITE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 86T22P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 86T22P
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5060 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x60-P-WHITE; Type: MARGRES-TIME 2.0-SKIRTING-8x60-P-WHITE; Type Id: 97370
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-BEIGE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-BEIGE:99013
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-NR-BEIGE; Reference: 89T24NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-NR-BEIGE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T24NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Level: 12280 mm; Offset From Wall: 0 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-NR-BEIGE; Type: MARGRES-TIME 2.0-SKIRTING-8x90-NR-BEIGE; Type Id: 97371
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-BLACK, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-BLACK:99272
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 11
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-NR-BLACK; Reference: 89T29NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-NR-BLACK
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T29NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 12280 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-NR-BLACK; Type: MARGRES-TIME 2.0-SKIRTING-8x90-NR-BLACK; Type Id: 97372
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-CARBON, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-CARBON:99380
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 11
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-NR-CARBON; Reference: 89T28NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-NR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-NR-CARBON
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T28NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 12280 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-NR-CARBON; Type: MARGRES-TIME 2.0-SKIRTING-8x90-NR-CARBON; Type Id: 97373
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-CREAM, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-CREAM:99511
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING-PROFILES : 9.5
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING-8X90-NR-CREAM; Reference: 89T23NR; Type Name: MARGRES-TIME 2.0-SKIRTING-8x90-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING-8X90-NR-CREAM
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: 89T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: 89T23NR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 12280 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING-8x90-NR-CREAM; Type: MARGRES-TIME 2.0-SKIRTING-8x90-NR-CREAM; Type Id: 97374
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING-8x90-NR-SILVER:99906
In: Level 1
Type - Analysis Results - Length per Piece: 896 mm
