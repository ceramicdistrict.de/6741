Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [VersionGUID: 0f9c4400-30b7-4495-817c-4245db5144dc, NumberOfSaves: 68], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: MARGRES-TIME 2.0-BASE.ifc
Time: 2025-08-07T10:22:15
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-BEIGE, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-BEIGE:136828
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - Reference: 36T24NR; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-BEIGE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-BLACK:136913
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-CARBON, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-CARBON:136991
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T28NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-CARBON

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-CREAM:137053
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-DOVE, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-DOVE:137108
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T25NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T25NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-DOVE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-GREY, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-GREY:137170
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T27NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T27NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-GREY

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-SILVER:137225
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-SNOW:137303
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-SNOW

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-WHITE, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-NR-WHITE:137351
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T22NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-NR-WHITE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-BEIGE, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-BEIGE:136836
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T24P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-BEIGE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-BLACK:136921
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-CARBON, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-CARBON:136999
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T28P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-CARBON

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-CREAM:137061
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-DOVE, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-DOVE:137116
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T25P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T25P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-DOVE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-GREY, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-GREY:137178
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T27P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T27P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-GREY

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-SILVER:137233
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-SNOW:137311
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-SNOW

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-WHITE, Basic Wall:MARGRES-TIME 2.0-BASE-30X60-P-WHITE:137359
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T22P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T22P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-30X60-P-WHITE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-BLACK:136874
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-NR-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-CREAM:136968
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-NR-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-SILVER:137147
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-NR-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-SNOW:137257
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-NR-SNOW

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-WHITE, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-NR-WHITE:137335
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T22NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-NR-WHITE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-BLACK:136882
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-P-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-CREAM:136976
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-P-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-SILVER:137155
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-P-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-SNOW:137265
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-P-SNOW

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-WHITE, Basic Wall:MARGRES-TIME 2.0-BASE-60X120-P-WHITE:137343
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T22P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T22P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X120-P-WHITE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-BEIGE, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-BEIGE:136851
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T24NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-BEIGE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-BLACK:136936
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-CARBON, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-CARBON:137014
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T28NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-CARBON

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-CREAM:137076
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-DOVE, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-DOVE:137124
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T25NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T25NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-DOVE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-GREY, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-GREY:137186
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T27NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T27NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-GREY

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-SILVER:137241
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-SNOW:137319
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-SNOW

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-WHITE, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-NR-WHITE:137367
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T22NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-NR-WHITE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-BEIGE, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-BEIGE:136866
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T24P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-BEIGE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-BLACK:136944
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-CARBON, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-CARBON:137022
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T28P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-CARBON

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-CREAM:137084
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-DOVE, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-DOVE:137132
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T25P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T25P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-DOVE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-GREY, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-GREY:137194
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T27P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T27P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-GREY

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-SILVER:137249
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-SNOW:137327
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-SNOW

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-WHITE, Basic Wall:MARGRES-TIME 2.0-BASE-60X60-P-WHITE:137375
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T22P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T22P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-60X60-P-WHITE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-BEIGE, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-BEIGE:136890
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T24NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-NR-BEIGE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-BLACK:136952
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-NR-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-CARBON, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-CARBON:137030
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T28NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-NR-CARBON

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-CREAM:137092
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-NR-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-SILVER:137202
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-NR-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-NR-SNOW:137280
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-NR-SNOW

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-BEIGE, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-BEIGE:136898
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T24P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-P-BEIGE

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-BLACK, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-BLACK:136960
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-P-BLACK

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-CARBON, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-CARBON:137038
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T28P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-P-CARBON

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-CREAM, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-CREAM:137100
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-P-CREAM

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-SILVER, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-SILVER:137210
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-P-SILVER

# IfcCovering: Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-SNOW, Basic Wall:MARGRES-TIME 2.0-BASE-90X90-P-SNOW:137288
In: Level 1
Type - PredefinedType: CLADDING
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Material: MARGRES-TIME 2.0-BASE-90X90-P-SNOW

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-BEIGE, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-BEIGE:136823
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-BEIGE
Type - Pset_CoveringCommon - Reference: 36T24NR; IsExternal: no
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-BLACK, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-BLACK:136908
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-CARBON, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-CARBON:136986
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-CARBON
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T28NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-CREAM, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-CREAM:137048
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-DOVE, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-DOVE:137103
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-DOVE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T25NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T25NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-GREY, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-GREY:137165
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-GREY
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T27NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T27NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-SILVER, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-SILVER:137220
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-SNOW, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-SNOW:137298
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-NR-WHITE, Floor:MARGRES-TIME 2.0-BASE-30X60-NR-WHITE:137346
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-NR-WHITE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T22NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-BEIGE, Floor:MARGRES-TIME 2.0-BASE-30X60-P-BEIGE:136831
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-BEIGE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T24P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-BLACK, Floor:MARGRES-TIME 2.0-BASE-30X60-P-BLACK:136916
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-CARBON, Floor:MARGRES-TIME 2.0-BASE-30X60-P-CARBON:136994
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-CARBON
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T28P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-CREAM, Floor:MARGRES-TIME 2.0-BASE-30X60-P-CREAM:137056
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-DOVE, Floor:MARGRES-TIME 2.0-BASE-30X60-P-DOVE:137111
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-DOVE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T25P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T25P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-GREY, Floor:MARGRES-TIME 2.0-BASE-30X60-P-GREY:137173
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-GREY
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T27P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T27P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-SILVER, Floor:MARGRES-TIME 2.0-BASE-30X60-P-SILVER:137228
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-SNOW, Floor:MARGRES-TIME 2.0-BASE-30X60-P-SNOW:137306
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-30X60-P-WHITE, Floor:MARGRES-TIME 2.0-BASE-30X60-P-WHITE:137354
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-30X60-P-WHITE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 36T22NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 36T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-NR-BLACK, Floor:MARGRES-TIME 2.0-BASE-60X120-NR-BLACK:136869
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-NR-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-NR-CREAM, Floor:MARGRES-TIME 2.0-BASE-60X120-NR-CREAM:136963
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-NR-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-NR-SILVER, Floor:MARGRES-TIME 2.0-BASE-60X120-NR-SILVER:137142
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-NR-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-NR-SNOW, Floor:MARGRES-TIME 2.0-BASE-60X120-NR-SNOW:137252
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-NR-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-NR-WHITE, Floor:MARGRES-TIME 2.0-BASE-60X120-NR-WHITE:137330
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-NR-WHITE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T22NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-P-BLACK, Floor:MARGRES-TIME 2.0-BASE-60X120-P-BLACK:136877
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-P-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-P-CREAM, Floor:MARGRES-TIME 2.0-BASE-60X120-P-CREAM:136971
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-P-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-P-SILVER, Floor:MARGRES-TIME 2.0-BASE-60X120-P-SILVER:137150
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-P-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-P-SNOW, Floor:MARGRES-TIME 2.0-BASE-60X120-P-SNOW:137260
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-P-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X120-P-WHITE, Floor:MARGRES-TIME 2.0-BASE-60X120-P-WHITE:137338
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X120-P-WHITE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 62T22P
Type - Pset_EnvironmentalImpactIndicators - Reference: 62T22P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-BEIGE, Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-BEIGE:136839
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-ASR-BEIGE
Type - Pset_CoveringCommon - Reference: 66T24ASR; IsExternal: yes
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T24ASR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-BLACK, Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-BLACK:136924
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-ASR-BLACK
Type - Pset_CoveringCommon - IsExternal: yes; Reference: 66T29ASR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T29ASR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-CARBON, Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-CARBON:137002
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-ASR-CARBON
Type - Pset_CoveringCommon - IsExternal: yes; Reference: 66T28ASR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T28ASR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-CREAM, Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-CREAM:137064
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-ASR-CREAM
Type - Pset_CoveringCommon - IsExternal: yes; Reference: 66T23ASR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T23ASR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-SILVER, Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-SILVER:137385
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-ASR-SILVER
Type - Pset_CoveringCommon - IsExternal: yes; Reference: 66T26ASR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T26ASR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-SNOW, Floor:MARGRES-TIME 2.0-BASE-60X60-ASR-SNOW:137378
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-ASR-SNOW
Type - Pset_CoveringCommon - IsExternal: yes; Reference: 66T21ASR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T21ASR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-CREAM, Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-CREAM:136854
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-E NR-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T23ENR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T23ENR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-GREY, Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-GREY:137135
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-E NR-GREY
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T27ENR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T27ENR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-SILVER, Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-SILVER:137213
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-E NR-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T26ENR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T26ENR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-SNOW, Floor:MARGRES-TIME 2.0-BASE-60X60-E NR-SNOW:137291
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-E NR-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T21ENR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T21ENR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-BEIGE, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-BEIGE:136846
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-BEIGE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T24NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-BLACK, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-BLACK:136931
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-CARBON, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-CARBON:137009
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-CARBON
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T28NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-CREAM, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-CREAM:137071
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-DOVE, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-DOVE:137119
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-DOVE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T25NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T25NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-GREY, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-GREY:137181
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-GREY
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T27NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T27NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-SILVER, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-SILVER:137236
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-SNOW, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-SNOW:137314
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-NR-WHITE, Floor:MARGRES-TIME 2.0-BASE-60X60-NR-WHITE:137362
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-NR-WHITE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T22NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T22NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-BEIGE, Floor:MARGRES-TIME 2.0-BASE-60X60-P-BEIGE:136861
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-BEIGE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T24P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-BLACK, Floor:MARGRES-TIME 2.0-BASE-60X60-P-BLACK:136939
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-CARBON, Floor:MARGRES-TIME 2.0-BASE-60X60-P-CARBON:137017
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-CARBON
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T28P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-CREAM, Floor:MARGRES-TIME 2.0-BASE-60X60-P-CREAM:137079
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-DOVE, Floor:MARGRES-TIME 2.0-BASE-60X60-P-DOVE:137127
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-DOVE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T25P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T25P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-GREY, Floor:MARGRES-TIME 2.0-BASE-60X60-P-GREY:137189
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-GREY
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T27P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T27P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-SILVER, Floor:MARGRES-TIME 2.0-BASE-60X60-P-SILVER:137244
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-SNOW, Floor:MARGRES-TIME 2.0-BASE-60X60-P-SNOW:137322
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-60X60-P-WHITE, Floor:MARGRES-TIME 2.0-BASE-60X60-P-WHITE:137370
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-60X60-P-WHITE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 66T22P
Type - Pset_EnvironmentalImpactIndicators - Reference: 66T22P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-NR-BEIGE, Floor:MARGRES-TIME 2.0-BASE-90X90-NR-BEIGE:136885
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-NR-BEIGE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T24NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T24NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-NR-BLACK, Floor:MARGRES-TIME 2.0-BASE-90X90-NR-BLACK:136947
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-NR-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T29NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T29NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-NR-CARBON, Floor:MARGRES-TIME 2.0-BASE-90X90-NR-CARBON:137025
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-NR-CARBON
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T28NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T28NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-NR-CREAM, Floor:MARGRES-TIME 2.0-BASE-90X90-NR-CREAM:137087
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-NR-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T23NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T23NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-NR-SILVER, Floor:MARGRES-TIME 2.0-BASE-90X90-NR-SILVER:137197
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-NR-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T26NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T26NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-NR-SNOW, Floor:MARGRES-TIME 2.0-BASE-90X90-NR-SNOW:137275
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-NR-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T21NR
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T21NR
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-P-BEIGE, Floor:MARGRES-TIME 2.0-BASE-90X90-P-BEIGE:136893
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-P-BEIGE
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T24P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T24P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-P-BLACK, Floor:MARGRES-TIME 2.0-BASE-90X90-P-BLACK:136955
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-P-BLACK
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T29P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T29P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-P-CARBON, Floor:MARGRES-TIME 2.0-BASE-90X90-P-CARBON:137033
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-P-CARBON
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T28P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T28P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-P-CREAM, Floor:MARGRES-TIME 2.0-BASE-90X90-P-CREAM:137095
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-P-CREAM
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T23P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T23P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-P-SILVER, Floor:MARGRES-TIME 2.0-BASE-90X90-P-SILVER:137205
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-P-SILVER
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T26P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T26P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES

# IfcCovering: Floor:MARGRES-TIME 2.0-BASE-90X90-P-SNOW, Floor:MARGRES-TIME 2.0-BASE-90X90-P-SNOW:137283
In: Level 1
Type - PredefinedType: FLOORING; Material: MARGRES-TIME 2.0-BASE-90X90-P-SNOW
Type - Pset_CoveringCommon - IsExternal: no; Reference: 99T21P
Type - Pset_EnvironmentalImpactIndicators - Reference: 99T21P
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
