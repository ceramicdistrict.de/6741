Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-03-31T18:22:55
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 07/2021
Text - Library Version: V00

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Identity Data - Author: StratBIM; Organization Description: CERAMIC TILES; Organization Name: MARGRES
Other - Category: Project Information; Project Issue Date: 07/2021
Text - Library Version: V00

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1604
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BEIGE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BEIGE:101279
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-BEIGE; Reference: B2553T23BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-BEIGE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T23BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T23BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5720 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BEIGE; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BEIGE; Type Id: 103664
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BLACK, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BLACK:103802
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-BLACK; Reference: B2553T29BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BLACK; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-BLACK
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T29BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T29BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5720 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BLACK; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-BLACK; Type Id: 103665
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CARBON, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CARBON:103877
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-CARBON; Reference: B2553T28BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CARBON; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-CARBON
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T28BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T28BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5720 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CARBON; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CARBON; Type Id: 103666
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CREAM, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CREAM:103952
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-CREAM; Reference: B2553T22BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-CREAM
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T22BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T22BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5720 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CREAM; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-CREAM; Type Id: 103667
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-DOVE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-DOVE:104014
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-DOVE; Reference: B2553T25BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-DOVE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-DOVE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T25BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T25BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 5720 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-DOVE; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-DOVE; Type Id: 103668
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-GREY, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-GREY:100791
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-GREY; Reference: B2553T27BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-GREY; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-GREY
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T27BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T27BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Level: 1020 mm; Offset From Wall: 0 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-GREY; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-GREY; Type Id: 103669
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SILVER, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SILVER:104068
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-SILVER; Reference: B2553T26BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SILVER; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-SILVER
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T26BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T26BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SILVER; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SILVER; Type Id: 103670
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SNOW, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SNOW:104148
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-SNOW; Reference: B2553T21BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SNOW; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-SNOW
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T21BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T21BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SNOW; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-SNOW; Type Id: 103671
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-WHITE, Wall Sweep:MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-WHITE:104262
In: Level 1
Type - Analysis Results - Length per Piece: 300.9 mm
Type - Constraints - Cut by Inserts: yes; Cuts Wall: yes; Default Setback: 0 mm
Type - Construction - Profile: MARGRES-TIME 2.0-SKIRTING SIT-IN-PROFILES : 15X30
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Manufacturer URL: www.margres.pt; Publication date: 07/2021; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V00
Type - Identity Data - Manufacturer: MARGRES; Model: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-WHITE; Reference: B2553T24BF; Type Name: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-WHITE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-SKIRTING SIT-IN-15X30-NR-WHITE
Type - Other - Category: Walls: Wall Sweeps; Family Name: Wall Sweep
Type - Pset_BuildingElementProxyCommon - Reference: B2553T24BF
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Walls: Wall Sweeps
Type - Pset_QuantityTakeOff - Reference: B2553T24BF
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Shape: Undefined; Depth: 1000 mm
Constraints - Level: Level 1; Offset From Wall: 0 mm; Offset From Level: 1020 mm
Dimensions - Length: 1000 mm
Other - Family: Wall Sweep; Family and Type: Wall Sweep: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-WHITE; Type: MARGRES-TIME 2.0-SKIRTING SIT-IN-15x30-NR-WHITE; Type Id: 103672
Phasing - Phase Created: New Construction
