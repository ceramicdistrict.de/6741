Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2025-03-31T18:56:04
Written by: ODA IFC SDK 22.8
Made in: 22.1.50.17 - Exporter 22.5.1.0 - Alternate UI 22.5.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1813
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcCovering: MARGRES-TIME 2.0-STEP TREAD GROOVED:30x120-NR-CREAM, MARGRES-TIME 2.0-STEP TREAD GROOVED:30x120-NR-CREAM:13124
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 300.9 mm; Thickness: 11 mm; Width: 1203.6 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 32T23DNR; Type Comments: Step Tread Grooved; Type Name: 30x120-NR-CREAM; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X120-NR-CREAM
Type - Other - Category: Generic Models; Family Name: MARGRES-TIME 2.0-STEP TREAD GROOVED
Type - Pset_CoveringCommon - Reference: 32T23DNR; Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X120-NR-CREAM; TotalThickness: 11 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32T23DNR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X120-NR-CREAM
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.384874 m2; Volume: 0.00395078 m3
Other - Family: MARGRES-TIME 2.0-STEP TREAD GROOVED; Family and Type: MARGRES-TIME 2.0-STEP TREAD GROOVED: 30x120-NR-CREAM; Type: 30x120-NR-CREAM; Type Id: 13076
Phasing - Phase Created: New Construction

# IfcCovering: MARGRES-TIME 2.0-STEP TREAD GROOVED:30x60-ASR-BEIGE, MARGRES-TIME 2.0-STEP TREAD GROOVED:30x60-ASR-BEIGE:13108
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 301.4 mm; Thickness: 10 mm; Width: 602.8 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 36T24DASR; Type Comments: Step Tread Grooved; Type Name: 30x60-ASR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X60-ASR-BEIGE
Type - Other - Category: Generic Models; Family Name: MARGRES-TIME 2.0-STEP TREAD GROOVED
Type - Pset_CoveringCommon - Reference: 36T24DASR; Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X60-ASR-BEIGE; TotalThickness: 10 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 36T24DASR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X60-ASR-BEIGE
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.193798 m2; Volume: 0.0018003 m3
Other - Family: MARGRES-TIME 2.0-STEP TREAD GROOVED; Family and Type: MARGRES-TIME 2.0-STEP TREAD GROOVED: 30x60-ASR-BEIGE; Type: 30x60-ASR-BEIGE; Type Id: 13054
Phasing - Phase Created: New Construction

# IfcCovering: MARGRES-TIME 2.0-STEP TREAD GROOVED:30x90-NR-BEIGE, MARGRES-TIME 2.0-STEP TREAD GROOVED:30x90-NR-BEIGE:13116
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 300.9 mm; Thickness: 11 mm; Width: 897 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 39T24DNR; Type Comments: Step Tread Grooved; Type Name: 30x90-NR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X90-NR-BEIGE
Type - Other - Category: Generic Models; Family Name: MARGRES-TIME 2.0-STEP TREAD GROOVED
Type - Pset_CoveringCommon - Reference: 39T24DNR; Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X90-NR-BEIGE; TotalThickness: 11 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 39T24DNR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-30X90-NR-BEIGE
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.287669 m2; Volume: 0.00294437 m3
Other - Family: MARGRES-TIME 2.0-STEP TREAD GROOVED; Family and Type: MARGRES-TIME 2.0-STEP TREAD GROOVED: 30x90-NR-BEIGE; Type: 30x90-NR-BEIGE; Type Id: 13006
Phasing - Phase Created: New Construction

# IfcCovering: MARGRES-TIME 2.0-STEP TREAD GROOVED:60x60-ASR-BEIGE, MARGRES-TIME 2.0-STEP TREAD GROOVED:60x60-ASR-BEIGE:13132
In: Level 1
Type - PredefinedType: FLOORING
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Length: 602.8 mm; Thickness: 10 mm; Width: 602.8 mm
Type - General - BIM Modeler: StratBIM; BIM Modeler URL: www.stratbim.com; Publication date: 03/2023; Region Africa: ALL; Region Antarctica: ALL; Region Asia: ALL; Region Europe: ALL; Region Middle East: ALL; Region North America: ALL; Region Oceania: ALL; Region South America: ALL; Version: V03
Type - Identity Data - Assembly Code: C3020; Manufacturer: MARGRES; Manufacturer URL: margres.com; Model: Time 2.0; Reference: 66T24DASR; Type Comments: Step Tread Grooved; Type Name: 60x60-ASR-BEIGE; URL: https://margres.com/en/products/time-2-0
Type - Materials and Finishes - Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-60X60-ASR-BEIGE
Type - Other - Category: Generic Models; Family Name: MARGRES-TIME 2.0-STEP TREAD GROOVED
Type - Pset_CoveringCommon - Reference: 66T24DASR; Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-60X60-ASR-BEIGE; TotalThickness: 10 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: MARGRES
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 66T24DASR
Classification: C3020 (Uniformat); Material: MARGRES-TIME 2.0-STEP TREAD GROOVED-60X60-ASR-BEIGE
Constraints - Elevation from Level: 0 mm; Level: Level 1; Offset from Host: 0 mm; Schedule Level: Level 1; Work Plane: Level : Level 1
Dimensions - Area: 0.378496 m2; Volume: 0.00361714 m3
Other - Family: MARGRES-TIME 2.0-STEP TREAD GROOVED; Family and Type: MARGRES-TIME 2.0-STEP TREAD GROOVED: 60x60-ASR-BEIGE; Type: 60x60-ASR-BEIGE; Type Id: 12982
Phasing - Phase Created: New Construction
